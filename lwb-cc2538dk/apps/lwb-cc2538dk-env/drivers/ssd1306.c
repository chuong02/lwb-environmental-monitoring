/*
 * ssd1306.c — Driver OLED SSD1306 128x64
 * Dùng i2c_sw.h (PB2=SCL, PB3=SDA)
 *
 * Font 5x7 chỉ hỗ trợ ASCII 32–90 (space đến Z, hoa).
 * Ký tự thường sẽ tự động đổi thành hoa.
 */

#include "ssd1306.h"
#include "i2c_sw.h"
#include "sys/clock.h"

/* ---------- Font 5x7 (ASCII 32..90) ---------- */
static const uint8_t font5x7[] = {
  0x00,0x00,0x00,0x00,0x00, /* ' ' */
  0x00,0x00,0x5F,0x00,0x00, /* '!' */
  0x00,0x07,0x00,0x07,0x00, /* '"' */
  0x14,0x7F,0x14,0x7F,0x14, /* '#' */
  0x24,0x2A,0x7F,0x2A,0x12, /* '$' */
  0x23,0x13,0x08,0x64,0x62, /* '%' */
  0x36,0x49,0x55,0x22,0x50, /* '&' */
  0x00,0x05,0x03,0x00,0x00, /* ''' */
  0x00,0x1C,0x22,0x41,0x00, /* '(' */
  0x00,0x41,0x22,0x1C,0x00, /* ')' */
  0x14,0x08,0x3E,0x08,0x14, /* '*' */
  0x08,0x08,0x3E,0x08,0x08, /* '+' */
  0x00,0x50,0x30,0x00,0x00, /* ',' */
  0x08,0x08,0x08,0x08,0x08, /* '-' */
  0x00,0x60,0x60,0x00,0x00, /* '.' */
  0x20,0x10,0x08,0x04,0x02, /* '/' */
  0x3E,0x51,0x49,0x45,0x3E, /* '0' */
  0x00,0x42,0x7F,0x40,0x00, /* '1' */
  0x42,0x61,0x51,0x49,0x46, /* '2' */
  0x21,0x41,0x45,0x4B,0x31, /* '3' */
  0x18,0x14,0x12,0x7F,0x10, /* '4' */
  0x27,0x45,0x45,0x45,0x39, /* '5' */
  0x3C,0x4A,0x49,0x49,0x30, /* '6' */
  0x01,0x71,0x09,0x05,0x03, /* '7' */
  0x36,0x49,0x49,0x49,0x36, /* '8' */
  0x06,0x49,0x49,0x29,0x1E, /* '9' */
  0x00,0x36,0x36,0x00,0x00, /* ':' */
  0x00,0x56,0x36,0x00,0x00, /* ';' */
  0x08,0x14,0x22,0x41,0x00, /* '<' */
  0x14,0x14,0x14,0x14,0x14, /* '=' */
  0x00,0x41,0x22,0x14,0x08, /* '>' */
  0x02,0x01,0x51,0x09,0x06, /* '?' */
  0x32,0x49,0x79,0x41,0x3E, /* '@' */
  0x7E,0x11,0x11,0x11,0x7E, /* 'A' */
  0x7F,0x49,0x49,0x49,0x36, /* 'B' */
  0x3E,0x41,0x41,0x41,0x22, /* 'C' */
  0x7F,0x41,0x41,0x22,0x1C, /* 'D' */
  0x7F,0x49,0x49,0x49,0x41, /* 'E' */
  0x7F,0x09,0x09,0x09,0x01, /* 'F' */
  0x3E,0x41,0x49,0x49,0x7A, /* 'G' */
  0x7F,0x08,0x08,0x08,0x7F, /* 'H' */
  0x00,0x41,0x7F,0x41,0x00, /* 'I' */
  0x20,0x40,0x41,0x3F,0x01, /* 'J' */
  0x7F,0x08,0x14,0x22,0x41, /* 'K' */
  0x7F,0x40,0x40,0x40,0x40, /* 'L' */
  0x7F,0x02,0x0C,0x02,0x7F, /* 'M' */
  0x7F,0x04,0x08,0x10,0x7F, /* 'N' */
  0x3E,0x41,0x41,0x41,0x3E, /* 'O' */
  0x7F,0x09,0x09,0x09,0x06, /* 'P' */
  0x3E,0x41,0x51,0x21,0x5E, /* 'Q' */
  0x7F,0x09,0x19,0x29,0x46, /* 'R' */
  0x46,0x49,0x49,0x49,0x31, /* 'S' */
  0x01,0x01,0x7F,0x01,0x01, /* 'T' */
  0x3F,0x40,0x40,0x40,0x3F, /* 'U' */
  0x1F,0x20,0x40,0x20,0x1F, /* 'V' */
  0x3F,0x40,0x38,0x40,0x3F, /* 'W' */
  0x63,0x14,0x08,0x14,0x63, /* 'X' */
  0x07,0x08,0x70,0x08,0x07, /* 'Y' */
  0x61,0x51,0x49,0x45,0x43  /* 'Z' */
};

/* ---------- Frame buffer 128x64 / 8 = 1024 byte ---------- */
static uint8_t _buf[1024];

/* ---------- Gửi lệnh / data lên SSD1306 ---------- */
static void oled_cmd(uint8_t cmd)
{
  i2c_sw_start();
  i2c_sw_write(SSD1306_I2C_ADDRESS << 1);
  i2c_sw_write(0x00);   /* Co=0, D/C=0 → command */
  i2c_sw_write(cmd);
  i2c_sw_stop();
}

/* ---------- API ---------- */
void ssd1306_init(void)
{
  clock_wait(CLOCK_SECOND / 10);  /* chờ nguồn ổn định */

  oled_cmd(0xAE);  /* Display OFF */
  oled_cmd(0xD5); oled_cmd(0x80);  /* Set display clock */
  oled_cmd(0xA8); oled_cmd(0x3F);  /* Multiplex ratio = 64 */
  oled_cmd(0xD3); oled_cmd(0x00);  /* Display offset = 0 */
  oled_cmd(0x40);                   /* Start line = 0 */
  oled_cmd(0x8D); oled_cmd(0x14);  /* Charge pump ON */
  oled_cmd(0x20); oled_cmd(0x00);  /* Memory mode: horizontal */
  oled_cmd(0xA1);  /* Segment re-map */
  oled_cmd(0xC8);  /* COM scan direction */
  oled_cmd(0xDA); oled_cmd(0x12);  /* COM pins */
  oled_cmd(0x81); oled_cmd(0xCF);  /* Contrast */
  oled_cmd(0xD9); oled_cmd(0xF1);  /* Pre-charge */
  oled_cmd(0xDB); oled_cmd(0x40);  /* VCOMH deselect */
  oled_cmd(0xA4);  /* Resume display from RAM */
  oled_cmd(0xA6);  /* Normal display (không đảo) */
  oled_cmd(0xAF);  /* Display ON */

  ssd1306_clear();
  ssd1306_display();
}

void ssd1306_clear(void)
{
  uint16_t i;
  for(i = 0; i < 1024; i++) _buf[i] = 0;
}

void ssd1306_display(void)
{
  uint16_t i;
  oled_cmd(0x21); oled_cmd(0); oled_cmd(127);  /* Column 0..127 */
  oled_cmd(0x22); oled_cmd(0); oled_cmd(7);    /* Page 0..7 */

  /* Gửi 16 byte mỗi transaction để giảm overhead START/STOP */
  for(i = 0; i < 1024; ) {
    uint8_t chunk;
    i2c_sw_start();
    i2c_sw_write(SSD1306_I2C_ADDRESS << 1);
    i2c_sw_write(0x40);   /* D/C=1 → data */
    for(chunk = 0; chunk < 16; chunk++) {
      i2c_sw_write(_buf[i++]);
    }
    i2c_sw_stop();
  }
}

void ssd1306_draw_pixel(uint8_t x, uint8_t y, uint8_t on)
{
  if(x >= 128 || y >= 64) return;
  if(on) _buf[x + (y / 8) * 128] |=  (1 << (y & 7));
  else   _buf[x + (y / 8) * 128] &= ~(1 << (y & 7));
}

void ssd1306_draw_char(uint8_t x, uint8_t y, char c, uint8_t size)
{
  uint16_t idx;
  uint8_t i, j, sx, sy;

  /* Chuyển thường → hoa */
  if(c >= 'a' && c <= 'z') c -= 32;
  if(c < 32 || c > 90) c = '?';

  idx = (uint16_t)(c - 32) * 5;
  for(i = 0; i < 5; i++) {
    uint8_t col = font5x7[idx + i];
    for(j = 0; j < 7; j++) {
      if(col & (1 << j)) {
        for(sx = 0; sx < size; sx++)
          for(sy = 0; sy < size; sy++)
            ssd1306_draw_pixel(x + i*size + sx, y + j*size + sy, 1);
      }
    }
  }
}

void ssd1306_draw_text(uint8_t x, uint8_t y, const char *text, uint8_t size)
{
  while(*text) {
    ssd1306_draw_char(x, y, *text, size);
    x += 6 * size;
    text++;
  }
}

void ssd1306_draw_hline(uint8_t x, uint8_t y, uint8_t len)
{
  uint8_t i;
  for(i = 0; i < len; i++) ssd1306_draw_pixel(x + i, y, 1);
}
